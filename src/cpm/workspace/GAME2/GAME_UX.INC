{ Xtase-fgalliat Game UX include @May 2020 }
{ requires XTSYATLJ.INC }
{ requires type mStr }

const
 SC_WIDTH = 53; { main screen dims }
 SC_HEIGHT = 16;

procedure waitRelPadDir;
 var direction : integer;
begin
 repeat
   pollJoypad;
   direction := getJoyDir;
   bDelay(10);
 until ( direction = 0 );
end;

procedure waitRelPadBtn;
 var button : integer;
begin
 repeat
   pollJoypad;
   button    := getJoyBtn;
   bDelay(10);
 until ( button = 0 );
end;

procedure waitPressPadBtn;
 var button : integer;
begin
 repeat
   pollJoypad;
   button    := getJoyBtn;
   bDelay(10);
 until ( button <> 0 );
end;

procedure DrawBox(X1,Y1,X2,Y2: Integer);
 var I: Integer; 
 begin 
   GotoXY(X1, Y1); 
   for I := X1 to X2 do write ( '~' ); 
   for I := Y1+1 to Y2 do 
     begin 
       GotoXY(X1,I); Write('|'); 
       GotoXY(X2,I); Write('|'); 
     end; 
   GotoXY(X1,Y2);
   for I := X1 to X2 do Write('~'); 
   GotoXY(X1,Y1); Write('O');
   GotoXY(X2,Y1); Write('\');
   GotoXY(X1,Y2); Write('\');
   GotoXY(X2,Y2); Write('O');
 end;

function confirmBox(msg: mStr) : boolean;
var
 x,y,w,h : integer;
 button : integer;
 direction : integer;
 value : boolean; 
begin

 waitRelPadBtn;
 
  w := length( msg ) + 4;
  h := 4;
  x := (SC_WIDTH - w) div 2;
  y := (SC_HEIGHT - h) div 2; 

  drawBox( x, y, x+w-1, y+h-1 ); 
  GotoXY(x+2, y+1); write( msg );
  {                         0123456}
  GotoXY(x+2, y+2); write( '  No   Yes ' );
  value := false;
  
  repeat
    if not value then
    begin
     GotoXY(x+2, y+2); write( '>' );
     GotoXY(x+2+5, y+2); write( ' ' );
    end
    else
    begin
     GotoXY(x+2, y+2); write( ' ' );
     GotoXY(x+2+5, y+2); write( '>' );
    end;
    
    pollJoypad;
    button    := getJoyBtn;
    direction := getJoyDir;
    if ( direction = RIGHT ) then value := true
    else if ( direction = LEFT ) then value := false;
    bDelay(50);
  until ( button <> 0 );  

  waitRelPadBtn;
 

  confirmBox := value;
end;